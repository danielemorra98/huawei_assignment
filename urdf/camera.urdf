Commit message: some tidy up

File: urdf/camera.urdf (robot description, URDF)
Before this commit: robot camera, 3 links, 2 joints
Links:
- removed link cylinder
Joints:
- removed joint joint2
